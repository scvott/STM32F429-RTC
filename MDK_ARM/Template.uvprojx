# Keil uVision project Template.uvprojx, settings and files
target tamplate (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: firstProsect +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_STM32F429I_DISCO
  c include: ..\User;..\CMSIS;..\library;..\library\driver;..\library\driver\inc;..\library\Discovery;..\library\Discovery\inc;..\FreeRTOSv10.0.0\FreeRTOS\Source\include;..\FreeRTOSv10.0.0\FreeRTOS\Demo\CORTEX_M4F_STM32F407ZG-SK;..\FreeRTOSv10.0.0\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\library\User_code\UART_LOG\inc;..\library\User_code\delay\inc;..\HARDWARE\RTC;..\HARDWARE\RTC
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CMSIS
    ../CMSIS/: startup_stm32f429_439xx.s
  group Driver
    ../library/driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Discovery
    ../library/Discovery/src/: stm32f429i_discovery.c stm32f429i_discovery_ioe.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c
  group Debug_log
    ../library/User_code/UART_LOG/src/: UART_LOG.c
  group delay
    ../library/User_code/delay/src/: delay.c
  group HARDWARE
    ../HARDWARE/RTC/: tm_stm32f4_rtc.c attributes.h tm_stm32f4_disco.c tm_stm32f4_gpio.c
